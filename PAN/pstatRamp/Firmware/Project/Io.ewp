# IAR project Io.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xF ST STM32F103xF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; ..\Comms; ..\IO; ..\Model; ..\ScriptEngine; ..\Controller; ..\library\CMSIS\Core\CM3\; ..\library\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Io.bin
  prebuild: getversion.bat "$PROJ_DIR$"
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DevBoard (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER; DEV_BOARD
  prebuild: "getversion.bat"
  ILINK.IlinkIcfFile: config\STM32F10x_DevBoard.icf
  group (top)
    ./: main.c stm32f10x_conf.h tick.c timer.c
  group CMSIS
    ../library/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
    ../library/CMSIS/Core/CM3/: system_stm32f10x.c
  group Comms
    ../Comms/: cd_class.c command.c usb_buffer.c usb_dev_desc.c usb_hooks.c usb_hw.c usb_t9.c
  group Controller
    ../Controller/: Controller.c
  group Io
    ../IO/: adc.c barcode.c bmp085.c button.c buzzer.c cpld.c drawer.c emagnet.c ioPstat.c power.c pstatAdc.c pstatDac.c reservoir.c spi1.c uart1.c
  group Model
    ../Model/: Logger.c ModelTime.c peltier.c ScriptDisk.c util.c
  group Other
    ./: readme.txt
    config/: STM32F10x_FLASH.icf
  group ScriptEngine
    ../ScriptEngine/: ScriptEngine.c
  group StdPeriph_Driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Vectors
    ./: stm32f10x_it.c
